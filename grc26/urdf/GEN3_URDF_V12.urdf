Commit message: update urdf

File: grc26/urdf/GEN3_URDF_V12.urdf (robot description, URDF)
Before this commit: robot GEN3_URDF_V12, 10 links, 9 joints
Links:
- link EndEffector_Link: mass 0.595 -> 1.195
